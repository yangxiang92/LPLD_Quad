# IAR project LPLD_Quad_V2_K60.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPLD_K60
  ICCARM.CCIncludePath2: ..\source\app; ..\source\module; ..\source\lib\CPU; ..\source\lib\common; ..\source\lib\LPLD; ..\source\lib\LPLD\HW; ..\source\lib\LPLD\DEV; ..\source\lib\uCOS-II\Ports; ..\source\lib\uCOS-II\Source; ..\source\lib\FatFs; ..\source\lib\FatFs\option; ..\source\lib\USB\common; ..\source\lib\USB\driver; ..\source\lib\USB\descriptor; ..\source\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPLD_Quad_V2_K60.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\source\lib\iar_config_files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\source\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: LPLD_Quad_V2_K60.bin
  ILINK.IlinkIcfFile: ..\source\lib\iar_config_files\LPLD_BOOT_K60DN512.icf
configuration FLASH_MINE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\source\app; ..\source\app\Control; ..\source\app\Others; ..\source\app\Communicate; ..\source\app\Algorithm; ..\source\app\SignalProcess; ..\source\module; ..\source\module\anbt_dmp; ..\source\module\eMPL; ..\source\lib\CPU; ..\source\lib\common; ..\source\lib\LPLD; ..\source\lib\LPLD\HW; ..\source\lib\LPLD\DEV; ..\source\lib\uCOS-II\Ports; ..\source\lib\uCOS-II\Source; ..\source\lib\FatFs; ..\source\lib\FatFs\option; ..\source\lib\USB\common; ..\source\lib\USB\driver; ..\source\lib\USB\descriptor; ..\source\lib\USB\class; ..\source\lib\MyLib
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: ..\source\lib\iar_config_files\LPLD_K60DN512_FLASH_MINE.icf
  group app
    ../source/app/: includes.h k60_card.h LPLD_Quad_V2.c LPLD_Quad_V2.h
  group app/Algorithm
    ../source/app/Algorithm/: algorithm.h attitude.c attitude.h quaternion.c quaternion.h sensorfusion.c sensorfusion.h
  group app/Communicate
    ../source/app/Communicate/: communicate.h dataframe.c dataframe.h decodedata.c decodedata.h myqueue.c myqueue.h uartqueue.c uartqueue.h uploaddata.c uploaddata.h
  group app/Control
    ../source/app/Control/: control.h ctrl.c ctrl.h pid.c pid.h
  group app/Others
    ../source/app/Others/: exception.c exception.h others.h param.c param.h sysflag.c sysflag.h
  group app/SignalProcess
    ../source/app/SignalProcess/: accfilter.c accfilter.h ADNS3080data.c ADNS3080data.h AK8975Cdata.c AK8975Cdata.h flowdata.c flowdata.h flowfilter.c flowfilter.h getoffset.c getoffset.h gyrfilter.c gyrfilter.h magfilter.c magfilter.h MPU6050data.c MPU6050data.h MS5611data.c MS5611data.h signalprocess.h WFLY_RCdata.c WFLY_RCdata.h
  group lib/common
    ../source/lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../source/lib/CPU/: MK60DZ10.h startup_K60.s system_MK60DZ10.c system_MK60DZ10.h
  group lib/LPLD
    ../source/lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../source/lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
  group lib/LPLD/HW
    ../source/lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_SYSTICK.c HW_SYSTICK.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
  group lib/MyLib
    ../source/lib/MyLib/: MyLib.c MyLib.h
  group module
    ../source/module/: ADNS3080.c ADNS3080.h AK8975C_reg_map.h battery.c battery.h buzzer.c buzzer.h delay.c delay.h flash_rom.c flash_rom.h HCSR04.c HCSR04.h I2C_ope.c I2C_ope.h lights.c lights.h module.h MPU6050_reg_map.h MPU9150.c MPU9150.h MPU9150_IO.c MPU9150_IO.h MS5611.c MS5611.h MS5611_reg_map.h PWM.c PWM.h switches.c switches.h timer.c timer.h uart.c uart.h WFLY_RC.c WFLY_RC.h
